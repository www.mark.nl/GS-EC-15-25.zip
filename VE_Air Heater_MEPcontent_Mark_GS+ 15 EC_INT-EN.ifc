Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-05-17T12:15:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 17 12:15:21 2018 * Host: B3ROBRAWR3857 * Database: C:\Users\CTO\AppData\Local\Temp\{AE1EA3FA-3273-4DAC-82B9-B375F40AFA5D}\ifc * Database version: 5507 * Database creation date: Thu May 17 12:15:20 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu May 17 12:15:20 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 17 12:15:20 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcAirTerminal: GS+ 15 EC, VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN:GS+ 15 EC:1340369
In: V00
Type - Material: Color RGB 060-060-060, Color RGB 193-193-194, Color RGB 000-000-255
Type - Dimensions - Drain Diameter: 30 mm; Gas Diameter: 12.7 mm; Height: 410 mm; Length: 883 mm; Use Nominal Diameter: yes; Width: 760 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: Gas-fired high performance air heater with axial modulating fan; Article Type: GS+ 15 EC; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Gas-fired high performance air heater with axial modulating fan; EMCS Version: 4.0; ETIM Article Class: EC011395; Family Version: 11.14; GTIN: 87193336250818; Manufacturer: Mark; Manufacturer Art. No.: 5062508; Manufacturer URL: http://www.markclimate.com/air-heating/gas-fired/natural-gas-garage-heater-gs/; MEPcontent Class: AIR_HEATER; Model: GS+ 15 EC; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2018; Type Name: GS+ 15 EC; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Air Flow Rate: 0.388889 m3/s; Heating Power: 146389; Nominal Flow Rate: 0 m3/s
Type - Other - Category: Mechanical Equipment; Family Name: VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN; Thread Offset: 50 mm; Thread Size: 10 mm
Type - Pset_AirTerminalTypeCommon - Reference: GS+ 15 EC
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 7.9158 m2; Flue Gas Diameter: 80 mm; Supply Air Diameter: 80 mm; Volume: 0.479933 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; System Classification: Supply Air,Other,Undefined,Sanitary,Power
Mechanical - Flow - Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Model Properties - Pendant Length: 500 mm
Other - Back Clearance: 0 mm; Family: VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN: GS+ 15 EC; Family and Type: VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN: GS+ 15 EC; Length Bottom Clearance: 910 mm; Pendant Length Safe: 500 mm; Pendants Visible: yes; Reference Line Length: 32.5 mm; Reference Line Offset: 438.6 mm; Suspension Console Offset: 420 mm; Suspension Console Offset Safe: 0 mm; Top Clearance: 600 mm; Type: VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN: GS+ 15 EC; Type Id: VE_Air Heater_MEPcontent_Mark_GS+ 15-25_INT-EN: GS+ 15 EC; Vertical Offset: 0 mm; Vertical Offset Safe: 500 mm
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Condensate Pump: no; Show Service Space: no; Suspension Console: no
